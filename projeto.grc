options:
  parameters:
    generate_options: qt_gui
    id: projeto
    output_language: python
    title: Projetin
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '240'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '64'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: ''
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: ccc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: fff
  states: {}
- name: mywifi_ofdm_decode_mac_0
  id: mywifi_ofdm_decode_mac
  parameters:
    debug: 'False'
  states: {}
- name: mywifi_ofdm_decode_signal_0
  id: mywifi_ofdm_decode_signal
  parameters:
    debug: 'False'
  states: {}
- name: mywifi_ofdm_equalize_symbols_0
  id: mywifi_ofdm_equalize_symbols
  parameters:
    debug: 'False'
  states: {}
- name: mywifi_ofdm_parse_mac_0
  id: mywifi_ofdm_parse_mac
  parameters:
    debug: 'False'
  states: {}
- name: mywifi_ofdm_sync_long_0
  id: mywifi_ofdm_sync_long
  parameters:
    debug: 'False'
    freq_est: '128'
    sync_length: '320'
  states: {}
- name: mywifi_ofdm_sync_short_0
  id: mywifi_ofdm_sync_short
  parameters:
    debug: 'False'
    max_samples: '5200'
    min_plateau: '2'
    threshold: '0.8'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '12345'
    type: TCP_SERVER
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '5.22'
    gain0: '30'
    samp_rate: 20M
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_1, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0, '0', mywifi_ofdm_sync_short_0, in0]
- [blocks_delay_1, '0', mywifi_ofdm_sync_long_0, in0]
- [blocks_divide_xx_0, '0', mywifi_ofdm_sync_short_0, in1]
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_null_source_0, '0', mywifi_ofdm_equalize_symbols_0, in]
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_null_sink_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_1, '0', blocks_divide_xx_0, '1']
- [mywifi_ofdm_decode_mac_0, MAC PDU (PMT blob), mywifi_ofdm_parse_mac_0, in]
- [mywifi_ofdm_decode_signal_0, out, mywifi_ofdm_decode_mac_0, in]
- [mywifi_ofdm_equalize_symbols_0, out, mywifi_ofdm_decode_signal_0, in]
- [mywifi_ofdm_parse_mac_0, out, network_socket_pdu_0, pdus]
- [mywifi_ofdm_sync_long_0, out, blocks_stream_to_vector_0, '0']
- [mywifi_ofdm_sync_short_0, out, blocks_delay_1, '0']
- [mywifi_ofdm_sync_short_0, out, mywifi_ofdm_sync_long_0, in1]
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
