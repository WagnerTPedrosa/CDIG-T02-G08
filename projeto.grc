options:
  parameters:
    generate_options: qt_gui
    id: projeto
    output_language: python
    snippets: {after_init: "self.epy_block_0.pluto_source = self.iio_pluto_source_0\nself.epy_block_0.set_top_block(self)"}
    title: Not titled yet
  states: {}

blocks:
- name: PlutoSDR_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '35'
  states: {}
- name: algorithm
  id: variable_qtgui_chooser
  parameters:
    label: algorithm
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: WiFi Channel
    labels: '[''CH1(2.412GHz)'', ''CH2(2.417GHz)'', ''CH3(2.422GHz)'', ''CH4(2.427GHz)'', ''CH5(2.432GHz)'', ''CH6(2.437GHz)'', ''CH7(2.442GHz)'', ''CH8(2.447GHz)'', ''CH9(2.452GHz)'', ''CH10(2.457GHz)'', ''CH11(2.462GHz)'', ''CH12(2.467GHz)'', ''CH13(2.472GHz)'', ''CH14(2.484GHz)'', ''CH32(5.16e9)'', ''CH36(5.18e9)'', ''CH40(5.20e9)'', ''CH44(5.22e9)'', ''CH48(5.24e9)'', ''CH52(5.26e9)'', ''CH56(5.28e9)'', ''CH60(5.30e9)'', ''CH64(5.32e9)'', ''CH68(5.34e9)'', ''CH96(5.48e9)'', ''CH100(5.50e9)'', ''CH104(5.52e9)'', ''CH108(5.54e9)'', ''CH112(5.56e9)'', ''CH116(5.58e9)'', ''CH120(5.60e9)'', ''CH124(5.62e9)'', ''CH128(5.64e9)'', ''CH132(5.66e9)'', ''CH136(5.68e9)'', ''CH140(5.70e9)'', ''CH144(5.72e9)'', ''CH149(5.745e9)'', ''CH153(5.765e9)'', ''CH157(5.785e9)'', ''CH161(5.805e9)'', ''CH165(5.825e9)'', ''CH169(5.845e9)'', ''CH173(5.865e9)'', ''CH177(5.885e9)'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5160000000.0, 5180000000.0, 5200000000.0, 5220000000.0, 5240000000.0, 5260000000.0, 5280000000.0, 5300000000.0, 5320000000.0, 5340000000.0, 5480000000.0, 5500000000.0, 5520000000.0, 5540000000.0, 5560000000.0, 5580000000.0, 5600000000.0, 5620000000.0, 5640000000.0, 5660000000.0, 5680000000.0, 5700000000.0, 5720000000.0, 5745000000.0, 5765000000.0, 5785000000.0, 5805000000.0, 5825000000.0, 5845000000.0, 5865000000.0, 5885000000.0]'
    type: real
    value: 2.437e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: Sync Short Threshold
    start: '0.1'
    step: '0.01'
    stop: '0.99'
    value: '0.56'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '240'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: 'Wireshark live: wireshark /tmp/wifi_live.pcap'
    file: /home/wagner/Desktop/FEUP/MEEC/4_Ano/1semestre/CDIG/CDIG-T02-G08/data.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wagner/Desktop/FEUP/MEEC/4_Ano/1semestre/CDIG/Wifi_Project_Baseband_recordings/Wifi_Project_Baseband_recordings/Sample3_20MHz_Channel100.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import threading


      class blk(gr.sync_block):
          """WiFi Channel Sweeper - Varre canais 2.4 GHz e 5 GHz automaticamente"""

          def __init__(self, pluto_source=None, interval_seconds=10):
              """
              pluto_source: Referência ao bloco PlutoSDR Source
              interval_seconds: Tempo em cada canal (default 10s)
              """
              gr.sync_block.__init__(
                  self,
                  name='WiFi Channel Sweeper',
                  in_sig=None,
                  out_sig=None
              )
              
              self.pluto_source = pluto_source
              self.top_block = None  # Será detectado automaticamente
              self.interval = interval_seconds
              self.running = False
              self.sweep_thread = None
              
              # Canais WiFi 2.4 GHz (1-11)
              self.channels_24ghz = {
                  1: (2.412e9, '2.4GHz'),
                  2: (2.417e9, '2.4GHz'),
                  3: (2.422e9, '2.4GHz'),
                  4: (2.427e9, '2.4GHz'),
                  5: (2.432e9, '2.4GHz'),
                  6: (2.437e9, '2.4GHz'),
                  7: (2.442e9, '2.4GHz'),
                  8: (2.447e9, '2.4GHz'),
                  9: (2.452e9, '2.4GHz'),
                  10: (2.457e9, '2.4GHz'),
                  11: (2.462e9, '2.4GHz'),
              }
              
              # Canais 5 GHz mais comuns (802.11a/n/ac)
              self.channels_5ghz = {
                  36: (5.180e9, '5GHz'),
                  40: (5.200e9, '5GHz'),
                  44: (5.220e9, '5GHz'),
                  48: (5.240e9, '5GHz'),
                  52: (5.260e9, '5GHz'),
                  56: (5.280e9, '5GHz'),
                  60: (5.300e9, '5GHz'),
                  64: (5.320e9, '5GHz'),
                  149: (5.745e9, '5GHz'),
                  153: (5.765e9, '5GHz'),
                  157: (5.785e9, '5GHz'),
                  161: (5.805e9, '5GHz'),
                  165: (5.825e9, '5GHz'),
              }
              
              # Inicia a thread de detecção e sweep com delay
              if pluto_source:
                  self.sweep_thread = threading.Thread(target=self._init_and_sweep, daemon=True)
                  self.sweep_thread.start()
          
          def _init_and_sweep(self):
              """Detecta o top_block e inicia o sweep (com delay para inicialização)"""
              # Aguarda 2 segundos para o flowgraph inicializar completamente
              time.sleep(2)
              
              # Tenta detectar o top_block
              try:
                  import inspect
                  frame = inspect.currentframe()
                  for _ in range(15):  # Procura nos frames
                      if frame is None:
                          break
                      if 'self' in frame.f_locals:
                          obj = frame.f_locals['self']
                          if hasattr(obj, 'set_freq') and hasattr(obj, 'iio_pluto_source_0'):
                              self.top_block = obj
                              print(f"[SWEEP] Top block detectado: {type(obj).__name__}")
                              break
                      frame = frame.f_back
              except Exception as e:
                  print(f"[SWEEP] Erro ao detectar top_block: {e}")
              
              # Se não detectou, tenta obter do parent do pluto_source
              if self.top_block is None and self.pluto_source:
                  try:
                      # Navega na hierarquia do GNU Radio
                      if hasattr(self.pluto_source, 'to_basic_block'):
                          basic_block = self.pluto_source.to_basic_block()
                          if hasattr(basic_block, 'detail'):
                              detail = basic_block.detail()
                              # Tenta acessar o flowgraph
                              if hasattr(detail, 'owner'):
                                  parent = detail.owner()
                                  if hasattr(parent, 'set_freq'):
                                      self.top_block = parent
                                      print(f"[SWEEP] Top block obtido via hierarquia GNU Radio")
                  except Exception as e:
                      print(f"[SWEEP] Não foi possível obter top_block via hierarquia: {e}")
              
              if self.top_block and self.pluto_source:
                  self.start_sweep()
              else:
                  print("[SWEEP ERRO] Não foi possível detectar o top_block automaticamente")
                  print(f"[SWEEP DEBUG] pluto_source={self.pluto_source}, top_block={self.top_block}")
          
          def start_sweep(self):
              """Inicia o sweep automático"""
              if not self.running and self.pluto_source and self.top_block:
                  self.running = True
                  self.sweep_thread = threading.Thread(target=self._sweep_loop, daemon=True)
                  self.sweep_thread.start()
                  print("[SWEEP] Iniciado - varrendo 2.4 GHz (canais 1-11) e 5 GHz (canais 36-165)")
          
          def stop_sweep(self):
              """Para o sweep"""
              self.running = False
              if self.sweep_thread:
                  self.sweep_thread.join(timeout=2)
              print("[SWEEP] Parado")
          
          def _sweep_loop(self):
              """Loop principal do sweep"""
              while self.running:
                  # Varre canais 2.4 GHz
                  print(f"\n{'#'*60}")
                  print(f"# Varrendo banda 2.4 GHz (802.11b/g/n)")
                  print(f"{'#'*60}")
                  
                  for ch in sorted(self.channels_24ghz.keys()):
                      if not self.running:
                          break
                          
                      freq, band = self.channels_24ghz[ch]
                      try:
                          # Atualizar PlutoSDR
                          self.pluto_source.set_frequency(int(freq))
                          # Atualizar variável freq no flowgraph (para o equalizer)
                          self.top_block.set_freq(freq)
                          
                          print(f"\n{'='*60}")
                          print(f"[SWEEP] Canal {ch} ({band}) - {freq/1e9:.3f} GHz")
                          print(f"{'='*60}")
                          
                          time.sleep(self.interval)
                          
                      except Exception as e:
                          print(f"[SWEEP ERROR] Erro ao mudar para canal {ch}: {e}")
                  
                  # Varre canais 5 GHz
                  if self.running:
                      print(f"\n{'#'*60}")
                      print(f"# Varrendo banda 5 GHz (802.11a/n/ac)")
                      print(f"{'#'*60}")
                      
                      for ch in sorted(self.channels_5ghz.keys()):
                          if not self.running:
                              break
                              
                          freq, band = self.channels_5ghz[ch]
                          try:
                              # Atualizar PlutoSDR
                              self.pluto_source.set_frequency(int(freq))
                              # Atualizar variável freq no flowgraph (para o equalizer)
                              self.top_block.set_freq(freq)
                              
                              print(f"\n{'='*60}")
                              print(f"[SWEEP] Canal {ch} ({band}) - {freq/1e9:.3f} GHz")
                              print(f"{'='*60}")
                              
                              time.sleep(self.interval)
                              
                          except Exception as e:
                              print(f"[SWEEP ERROR] Erro ao mudar para canal {ch}: {e}")
                  
                  if self.running:
                      print(f"\n[SWEEP] Ciclo completo (2.4GHz + 5GHz) - reiniciando...")
          
          def stop(self):
              """Cleanup quando o flowgraph para"""
              self.stop_sweep()
              return True
          
          def work(self, input_items, output_items):
              """Não processa samples"""
              return 0
    interval_seconds: '10'
    pluto_source: None
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from PyQt5 import Qt
      from gnuradio import qtgui
      from PyQt5 import QtCore
      from PyQt5.QtCore import QObject, pyqtSlot
      from gnuradio import blocks
      import pmt
      from gnuradio import blocks, gr
      from gnuradio import fft
      from gnuradio.fft import window
      from gnuradio import filter
      from gnuradio.filter import firdes
      from gnuradio import gr
      import sys
      import signal
      from PyQt5 import Qt
      from argparse import ArgumentParser
      from gnuradio.eng_arg import eng_float, intx
      from gnuradio import eng_notation
      import foo
      import ieee802_11



      # Custom message handler for WiFi info
      class wifi_info_printer(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="WiFi Info Printer",
                  in_sig=None,
                  out_sig=None)
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)
          
          def handle_msg(self, msg):
              try:
                  meta = pmt.car(msg)
                  ssid = pmt.dict_ref(meta, pmt.intern('ssid'), pmt.PMT_NIL)
                  freq = pmt.dict_ref(meta, pmt.intern('nominal frequency'), pmt.PMT_NIL)
                  
                  if not pmt.is_null(ssid) and not pmt.is_null(freq):
                      ssid_str = pmt.symbol_to_string(ssid)
                      freq_val = pmt.to_double(freq)
                      channel = self.freq_to_channel(freq_val)
                      print(f"SSID: {ssid_str}  |  Channel: {channel} ({freq_val/1e9:.2f} GHz)")
              except Exception as e:
                  pass
          
          def freq_to_channel(self, freq_hz):
              # 5 GHz band channels
              if 5000e6 < freq_hz < 6000e6:
                  channel = int((freq_hz - 5000e6) / 5e6)
                  return channel
              # 2.4 GHz band channels
              elif 2400e6 < freq_hz < 2500e6:
                  if freq_hz == 2484e6:
                      return 14
                  else:
                      return int((freq_hz - 2407e6) / 5e6)
              return "Unknown"
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1] * window_size'
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1] * window_size'
    type: fff
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: algorithm
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: '240'
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: threshold
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'False'
    buffer_size: '26768'
    filter_source: '''Auto'''
    frequency: int(freq)
    gain1: '''manual'''
    manual_gain1: PlutoSDR_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: usb:1.4.5
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '1']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_0, '0', ieee802_11_sync_short_0, '1']
- [fir_filter_xxx_0_0, '0', blocks_divide_xx_0, '1']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_parse_mac_0, out, epy_block_1, in]
- [ieee802_11_parse_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_1, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', blocks_delay_0, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
