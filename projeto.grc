options:
  parameters:
    generate_options: qt_gui
    id: projeto
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: algorithm
  id: variable_qtgui_chooser
  parameters:
    label: algorithm
    labels: '["ieee802_11.LS", "ieee802_11.LMS", "ieee802_11.Linear Comb", "ieee802_11.STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: WiFi Channel
    labels: '[''CH1(2.412GHz)'', ''CH2(2.417GHz)'', ''CH3(2.422GHz)'', ''CH4(2.427GHz)'', ''CH5(2.432GHz)'', ''CH6(2.437GHz)'', ''CH7(2.442GHz)'', ''CH8(2.447GHz)'', ''CH9(2.452GHz)'', ''CH10(2.457GHz)'', ''CH11(2.462GHz)'', ''CH12(2.467GHz)'', ''CH13(2.472GHz)'', ''CH14(2.484GHz)'', ''CH32(5.16e9)'', ''CH36(5.18e9)'', ''CH40(5.20e9)'', ''CH44(5.22e9)'', ''CH48(5.24e9)'', ''CH52(5.26e9)'', ''CH56(5.28e9)'', ''CH60(5.30e9)'', ''CH64(5.32e9)'', ''CH68(5.34e9)'', ''CH96(5.48e9)'', ''CH100(5.50e9)'', ''CH104(5.52e9)'', ''CH108(5.54e9)'', ''CH112(5.56e9)'', ''CH116(5.58e9)'', ''CH120(5.60e9)'', ''CH124(5.62e9)'', ''CH128(5.64e9)'', ''CH132(5.66e9)'', ''CH136(5.68e9)'', ''CH140(5.70e9)'', ''CH144(5.72e9)'', ''CH149(5.745e9)'', ''CH153(5.765e9)'', ''CH157(5.785e9)'', ''CH161(5.805e9)'', ''CH165(5.825e9)'', ''CH169(5.845e9)'', ''CH173(5.865e9)'', ''CH177(5.885e9)'']'
    num_opts: '0'
    options: '[2412000000, 2417000000, 2422000000, 2427000000, 2432000000, 2437000000, 2442000000, 2447000000, 2452000000, 2457000000, 2462000000, 2467000000, 2472000000, 2484000000, 5160000000, 5180000000, 5200000000, 5220000000, 5240000000, 5260000000, 5280000000, 5300000000, 5320000000, 5340000000, 5480000000, 5500000000, 5520000000, 5540000000, 5560000000, 5580000000, 5600000000, 5620000000, 5640000000, 5660000000, 5680000000, 5700000000, 5720000000, 5745000000, 5765000000, 5785000000, 5805000000, 5825000000, 5845000000, 5865000000, 5885000000]'
    type: int
    value: '2412000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: Sync Short Threshold
    start: '0.1'
    step: '0.01'
    stop: '0.99'
    value: '0.8'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '240'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/gnuradio_wireshark.fifo
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wagner/Desktop/FEUP/MEEC/4_Ano/1semestre/CDIG/Wifi_Project_Baseband_recordings/Wifi_Project_Baseband_recordings/Sample3_20MHz_Channel100.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from PyQt5 import Qt
      from gnuradio import qtgui
      from PyQt5 import QtCore
      from PyQt5.QtCore import QObject, pyqtSlot
      from gnuradio import blocks
      import pmt
      from gnuradio import blocks, gr
      from gnuradio import fft
      from gnuradio.fft import window
      from gnuradio import filter
      from gnuradio.filter import firdes
      from gnuradio import gr
      import sys
      import signal
      from PyQt5 import Qt
      from argparse import ArgumentParser
      from gnuradio.eng_arg import eng_float, intx
      from gnuradio import eng_notation
      import foo
      import ieee802_11
      from collections import defaultdict
      from datetime import datetime



      # Global statistics storage
      channel_stats = {
          'networks_per_channel': defaultdict(set),  # channel -> set of SSIDs
          'rssi_per_channel': defaultdict(list),     # channel -> list of RSSI values
          'rssi_per_network': defaultdict(list),     # SSID -> list of (timestamp, RSSI)
          'detection_count': defaultdict(int),       # SSID -> count
          'last_seen': {},                            # SSID -> timestamp
      }

      def get_channel_stats():
          """Returns formatted statistics about channel occupancy and signal strength"""
          return channel_stats

      def get_top_channels(n=5):
          """Returns top N channels by number of detected networks"""
          channel_counts = [(ch, len(ssids)) for ch, ssids in channel_stats['networks_per_channel'].items()]
          return sorted(channel_counts, key=lambda x: x[1], reverse=True)[:n]

      def get_best_channels_by_rssi(n=5):
          """Returns top N channels by average RSSI (signal strength)"""
          channel_avg_rssi = []
          for ch, rssi_list in channel_stats['rssi_per_channel'].items():
              if rssi_list:
                  avg_rssi = sum(rssi_list) / len(rssi_list)
                  channel_avg_rssi.append((ch, avg_rssi, len(rssi_list)))
          return sorted(channel_avg_rssi, key=lambda x: x[1], reverse=True)[:n]


      # Custom message handler for WiFi info
      class wifi_info_printer(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="WiFi Info Printer",
                  in_sig=None,
                  out_sig=None)
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)
          
          def handle_msg(self, msg):
              try:
                  meta = pmt.car(msg)
                  ssid = pmt.dict_ref(meta, pmt.intern('ssid'), pmt.PMT_NIL)
                  freq = pmt.dict_ref(meta, pmt.intern('nominal frequency'), pmt.PMT_NIL)
                  rssi = pmt.dict_ref(meta, pmt.intern('rssi'), pmt.PMT_NIL)
                  
                  # Debug: print all available keys in metadata
                  if False:  # Set to True for debugging
                      print(f"[DEBUG] Message metadata keys: {pmt.to_python(meta)}")
                  
                  if not pmt.is_null(ssid):
                      ssid_str = pmt.symbol_to_string(ssid)
                      timestamp = datetime.now()
                      
                      # Update detection count and last seen
                      channel_stats['detection_count'][ssid_str] += 1
                      channel_stats['last_seen'][ssid_str] = timestamp
                      
                      # Get frequency and channel info
                      channel = None
                      freq_val = None
                      
                      if not pmt.is_null(freq):
                          freq_val = pmt.to_double(freq)
                          channel = self.freq_to_channel(freq_val)
                      else:
                          # Try to get current frequency from metadata
                          current_freq = pmt.dict_ref(meta, pmt.intern('frequency'), pmt.PMT_NIL)
                          if not pmt.is_null(current_freq):
                              freq_val = pmt.to_double(current_freq)
                              channel = self.freq_to_channel(freq_val)
                      
                      # Track networks per channel (even if frequency is unknown, use estimated channel)
                      if channel is not None and channel != "Unknown":
                          channel_stats['networks_per_channel'][channel].add(ssid_str)
                          
                          # Track RSSI if available - try multiple fields
                          rssi_val = None
                          if not pmt.is_null(rssi):
                              rssi_val = pmt.to_double(rssi)
                          else:
                              # Try alternative RSSI fields
                              for rssi_key in ['snr', 'signal', 'rx_power']:
                                  rssi_alt = pmt.dict_ref(meta, pmt.intern(rssi_key), pmt.PMT_NIL)
                                  if not pmt.is_null(rssi_alt):
                                      rssi_val = pmt.to_double(rssi_alt)
                                      break
                          
                          if rssi_val is not None:
                              channel_stats['rssi_per_channel'][channel].append(rssi_val)
                              channel_stats['rssi_per_network'][ssid_str].append((timestamp, rssi_val))
                          # If no RSSI, don't add to rssi stats - only real signal strength data
                          
                          # Print detection
                          if rssi_val is not None:
                              print(f"SSID: {ssid_str}  |  Channel: {channel} ({freq_val/1e9:.2f} GHz)  |  RSSI: {rssi_val:.1f} dBm  |  Detections: {channel_stats['detection_count'][ssid_str]}")
                          else:
                              print(f"SSID: {ssid_str}  |  Channel: {channel} ({freq_val/1e9:.2f} GHz)  |  RSSI: N/A (estimated -70 dBm)  |  Detections: {channel_stats['detection_count'][ssid_str]}")
                      else:
                          # SSID detected but no channel info - still count it
                          print(f"SSID: {ssid_str}  |  Channel: Unknown  |  Detections: {channel_stats['detection_count'][ssid_str]}")
                          print(f"[WiFi Info] Warning: No frequency information for SSID {ssid_str}")
              except Exception as e:
                  print(f"[WiFi Info] Error processing message: {e}")
          
          def freq_to_channel(self, freq_hz):
              # 5 GHz band channels
              if 5000e6 < freq_hz < 6000e6:
                  channel = int((freq_hz - 5000e6) / 5e6)
                  return channel
              # 2.4 GHz band channels
              elif 2400e6 < freq_hz < 2500e6:
                  if freq_hz == 2484e6:
                      return 14
                  else:
                      return int((freq_hz - 2407e6) / 5e6)
              return "Unknown"
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1] * window_size'
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1] * window_size'
    type: fff
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: algorithm
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: '240'
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: threshold
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '20000000'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      # Sweep 

      from PyQt5 import QtCore
      from PyQt5.QtWidgets import QPushButton, QLabel, QVBoxLayout, QHBoxLayout, QWidget, QTextEdit
      import projeto_epy_block_1 as epy_block_1

      # Import matplotlib for graphing
      try:
          import matplotlib
          matplotlib.use('Qt5Agg')
          from matplotlib.backends.backend_qt5agg import FigureCanvasQTAgg as FigureCanvas
          from matplotlib.figure import Figure
          import matplotlib.pyplot as plt
          matplotlib_available = True
      except ImportError:
          print("[GRAPH] Matplotlib not available. Install with: pip install matplotlib")
          matplotlib_available = False

      # Channel sweep setup
      channels = [
          2412000000, 2417000000, 2422000000, 2427000000, 2432000000, 2437000000,
          2442000000, 2447000000, 2452000000, 2457000000, 2462000000, 2467000000,
          2472000000, 2484000000, 5160000000, 5180000000, 5200000000, 5220000000,
          5240000000, 5260000000, 5280000000, 5300000000, 5320000000, 5340000000,
          5480000000, 5500000000, 5520000000, 5540000000, 5560000000, 5580000000,
          5600000000, 5620000000, 5640000000, 5660000000, 5680000000, 5700000000,
          5720000000, 5745000000, 5765000000, 5785000000, 5805000000, 5825000000,
          5845000000, 5865000000, 5885000000
      ]
      channel_index = [0]
      sweep_active = [True]
      sweep_changing = [False]  # Flag to indicate sweep is changing frequency

      tb = self
      tb.resize(1200, 700)  # Ajuste o tamanho da janela principal conforme necessário
      time = 60000

      # Create status label
      status_label = QLabel(" SWEEP MODE - Scanning all channels...")
      status_label.setStyleSheet("QLabel { background-color: #4CAF50; color: white; padding: 10px; font-weight: bold; font-size: 14px; }")
      tb.top_layout.addWidget(status_label)

      # Create statistics display widgets
      stats_widget = QWidget()

      stats_layout = QVBoxLayout()
      stats_layout.setContentsMargins(5, 5, 5, 5)
      stats_layout.setSpacing(5)

      activity_label = QLabel("CHANNEL ACTIVITY - No data yet")
      activity_label.setStyleSheet("QLabel { background-color: #2196F3; color: white; padding: 4px; font-weight: bold; font-size: 11px; }")
      stats_layout.addWidget(activity_label)

      occupancy_label = QLabel("TOP CHANNELS BY NETWORK COUNT - No data yet")
      occupancy_label.setStyleSheet("QLabel { background-color: #9C27B0; color: white; padding: 4px; font-weight: bold; font-size: 11px; }")
      stats_layout.addWidget(occupancy_label)

      rssi_label = QLabel("BEST CHANNELS BY SIGNAL STRENGTH - No data yet")
      rssi_label.setStyleSheet("QLabel { background-color: #FF5722; color: white; padding: 4px; font-weight: bold; font-size: 11px; }")
      stats_layout.addWidget(rssi_label)

      stats_widget.setLayout(stats_layout)
      tb.top_layout.addWidget(stats_widget)

      # Create matplotlib graph widget

      if matplotlib_available:
          graph_widget = QWidget()
          graph_layout = QVBoxLayout()
          graph_layout.setContentsMargins(5, 5, 5, 5)
          graph_layout.setSpacing(5)

          graph_label = QLabel("REAL-TIME CHANNEL ANALYSIS")
          graph_label.setStyleSheet("QLabel { background-color: #607D8B; color: white; padding: 4px; font-weight: bold; font-size: 11px; }")
          graph_layout.addWidget(graph_label)

          # Create figure with two subplots
          fig = Figure(figsize=(10, 3.5), dpi=80)
          canvas = FigureCanvas(fig)

          ax1 = fig.add_subplot(121)  # Left: Networks per channel
          ax2 = fig.add_subplot(122)  # Right: Average RSSI per channel

          graph_layout.addWidget(canvas)
          graph_widget.setLayout(graph_layout)
          tb.top_layout.addWidget(graph_widget)

          def update_graph():
              """Update the real-time graphs"""
              try:
                  stats = epy_block_1.get_channel_stats()

                  # Clear previous plots
                  ax1.clear()
                  ax2.clear()

                  # Plot 1: Networks per channel
                  if stats['networks_per_channel'] and len(stats['networks_per_channel']) > 0:
                      channels_list = sorted(stats['networks_per_channel'].keys())
                      network_counts = [len(stats['networks_per_channel'][ch]) for ch in channels_list]

                      if channels_list and network_counts:
                          ax1.bar(range(len(channels_list)), network_counts, color='#2196F3', alpha=0.7)
                          ax1.set_xticks(range(len(channels_list)))
                          ax1.set_xticklabels([str(ch) for ch in channels_list], rotation=45, ha='right', fontsize=8)
                          ax1.set_xlabel('Channel', fontweight='bold')
                          ax1.set_ylabel('Number of Networks', fontweight='bold')
                          ax1.set_title('Networks Detected per Channel', fontweight='bold', fontsize=11)
                          ax1.grid(axis='y', alpha=0.3)

                          # Highlight most active channel
                          if network_counts:
                              max_idx = network_counts.index(max(network_counts))
                              ax1.bar(max_idx, network_counts[max_idx], color='#4CAF50', alpha=0.9)
                  else:
                      # Show "waiting for data" message
                      ax1.text(0.5, 0.5, 'Waiting for network detections...', 
                              ha='center', va='center', transform=ax1.transAxes, fontsize=12)
                      ax1.set_title('Networks Detected per Channel', fontweight='bold', fontsize=11)

                  # Plot 2: Average RSSI per channel
                  if stats['rssi_per_channel']:
                      rssi_channels = sorted([ch for ch, rssi_list in stats['rssi_per_channel'].items() if rssi_list])
                      
                      if rssi_channels and len(rssi_channels) > 0:
                          avg_rssi = [sum(stats['rssi_per_channel'][ch])/len(stats['rssi_per_channel'][ch])
                                     for ch in rssi_channels]

                          colors = ['#4CAF50' if rssi > -60 else '#FF9800' if rssi > -75 else '#F44336'
                                   for rssi in avg_rssi]

                          ax2.bar(range(len(rssi_channels)), avg_rssi, color=colors, alpha=0.7)
                          ax2.set_xticks(range(len(rssi_channels)))
                          ax2.set_xticklabels([str(ch) for ch in rssi_channels], rotation=45, ha='right', fontsize=8)
                          ax2.set_xlabel('Channel', fontweight='bold')
                          ax2.set_ylabel('Average RSSI (dBm)', fontweight='bold')
                          ax2.set_title('Signal Strength per Channel', fontweight='bold', fontsize=11)
                          ax2.grid(axis='y', alpha=0.3)
                          ax2.axhline(y=-60, color='green', linestyle='--', alpha=0.5, linewidth=1, label='Excellent')
                          ax2.axhline(y=-75, color='orange', linestyle='--', alpha=0.5, linewidth=1, label='Good')
                          ax2.legend(fontsize=8, loc='lower right')
                      else:
                          # Show "waiting for data" message
                          ax2.text(0.5, 0.5, 'Waiting for RSSI data...', 
                                  ha='center', va='center', transform=ax2.transAxes, fontsize=12)
                          ax2.set_title('Signal Strength per Channel', fontweight='bold', fontsize=11)
                  else:
                      # Show "waiting for data" message
                      ax2.text(0.5, 0.5, 'Waiting for RSSI data...', 
                              ha='center', va='center', transform=ax2.transAxes, fontsize=12)
                      ax2.set_title('Signal Strength per Channel', fontweight='bold', fontsize=11)

                  fig.tight_layout()
                  fig.subplots_adjust(top=0.9, bottom=0.1)
                  canvas.draw()
              except Exception as e:
                  # Silently handle errors when no data is available yet
                  pass

          # Store update function and canvas for later use
          tb._graph_update = update_graph
          tb._graph_canvas = canvas

      # Save original set_freq
      original_set_freq = tb.set_freq

      def update_status_label():
          if sweep_active[0]:
              status_label.setText(" SWEEP MODE - Scanning all channels...")
              status_label.setStyleSheet("QLabel { background-color: #4CAF50; color: white; padding: 10px; font-weight: bold; font-size: 14px; }")
          else:
              status_label.setText(" MANUAL MODE - Fixed channel selected")
              status_label.setStyleSheet("QLabel { background-color: #FF9800; color: white; padding: 10px; font-weight: bold; font-size: 14px; }")

      def custom_set_freq(freq):
          # Only pause if this is a manual change (not from sweep itself)
          if sweep_active[0] and not sweep_changing[0]:
              sweep_active[0] = False
              tb._sweep_timer.stop()
              update_status_label()
              print(f"[SWEEP] Paused! Manual change detected.")
              print("[SWEEP] Click 'Resume Sweep' button to continue.")
          original_set_freq(freq)

      tb.set_freq = custom_set_freq

      def update_statistics_display():
          """Update the GUI with latest statistics"""
          try:
              # Get top channels by network count
              top_channels = epy_block_1.get_top_channels(5)
              if top_channels:
                  most_active_ch, most_active_count = top_channels[0]
                  activity_label.setText(f" MOST ACTIVE CHANNEL: {most_active_ch} with {most_active_count} networks")

                  occupancy_text = "TOP CHANNELS BY NETWORK COUNT:\n"
                  for i, (ch, count) in enumerate(top_channels, 1):
                      occupancy_text += f"  {i}. Channel {ch}: {count} networks\n"
                  occupancy_label.setText(occupancy_text.strip())

              # Get best channels by RSSI
              best_rssi_channels = epy_block_1.get_best_channels_by_rssi(5)
              if best_rssi_channels:
                  rssi_text = " BEST CHANNELS BY SIGNAL STRENGTH:\n"
                  for i, (ch, avg_rssi, sample_count) in enumerate(best_rssi_channels, 1):
                      rssi_text += f"  {i}. Channel {ch}: {avg_rssi:.1f} dBm avg ({sample_count} samples)\n"
                  rssi_label.setText(rssi_text.strip())

              # Update graph if matplotlib is available
              if matplotlib_available and hasattr(tb, '_graph_update'):
                  tb._graph_update()
          except Exception as e:
              print(f"[STATS] Error updating display: {e}")

      def sweep_channel():
          if sweep_active[0]:
              try:
                  print(f"[SWEEP] Switching to channel {channel_index[0]+1}/{len(channels)}...")
                  sweep_changing[0] = True  # Set flag before changing
                  original_set_freq(channels[channel_index[0]])
                  sweep_changing[0] = False  # Clear flag after changing
                  print(f"[SWEEP] Now at: {channels[channel_index[0]]/1e9:.3f} GHz")
                  channel_index[0] = (channel_index[0] + 1) % len(channels)

                  # Update statistics display
                  update_statistics_display()
              except Exception as e:
                  sweep_changing[0] = False  # Clear flag on error
                  print(f"[SWEEP] ERROR: {e}")

      def resume_sweep():
          if not sweep_active[0]:
              sweep_active[0] = True
              tb._sweep_timer.start(time)
              update_status_label()
              print(f"[SWEEP] Resumed! Continuing sweep from channel {channel_index[0]+1}/{len(channels)}.")
          else:
              print("[SWEEP] Sweep is already active!")

      resume_button = QPushButton("Resume Sweep")
      resume_button.clicked.connect(resume_sweep)
      tb.top_layout.addWidget(resume_button)

      # Create statistics update timer (updates every 2 seconds)
      tb._stats_timer = QtCore.QTimer(tb)
      tb._stats_timer.timeout.connect(update_statistics_display)
      tb._stats_timer.start(2000)

      print("[SWEEP] Starting automatic WiFi channel sweep...")
      print(f"[SWEEP] Initial channel: {tb.freq / 1e9:.3f} GHz")
      print("[SWEEP] Use dropdown to pause or 'Resume Sweep' button to continue.")
      tb._sweep_timer = QtCore.QTimer(tb)
      tb._sweep_timer.timeout.connect(sweep_channel)
      tb._sweep_timer.start(time)
      print(f"[SWEEP] Timer started! Changing channel every {time / 1000} seconds...")
      print("[STATS] Statistics display updating every 2 seconds...")
    section: main_after_init
  states: {}
- name: snippet_0_0
  id: snippet
  parameters:
    code: |-
      # Snippet for wireshark

      import os
      import subprocess
      import time

      # Path to the pipe
      pipe_path = '/tmp/gnuradio_wireshark.fifo'

      # Remove old pipe if exists
      if os.path.exists(pipe_path):
          os.remove(pipe_path)

      # Create named pipe
      os.mkfifo(pipe_path)
      print(f"[WIRESHARK] Pipe created: {pipe_path}")

      # Launch Wireshark in background
      try:
          subprocess.Popen(['wireshark', '-k', '-i', pipe_path], 
                          stdout=subprocess.DEVNULL, 
                          stderr=subprocess.DEVNULL)
          print("[WIRESHARK] Wireshark launched! Wait for window to open...")
          time.sleep(2)  # Give Wireshark time to start
      except FileNotFoundError:
          print("[WIRESHARK] ERROR: Wireshark not found! Install with: sudo apt install wireshark")
      except Exception as e:
          print(f"[WIRESHARK] ERROR launching: {e}")
    section: init_before_blocks
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '1']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_0, '0', ieee802_11_sync_short_0, '1']
- [fir_filter_xxx_0_0, '0', blocks_divide_xx_0, '1']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_parse_mac_0, out, epy_block_1, in]
- [ieee802_11_parse_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_1, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', blocks_delay_0, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
