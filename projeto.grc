options:
  parameters:
    generate_options: qt_gui
    id: projeto
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: algorithm
  id: variable_qtgui_chooser
  parameters:
    label: algorithm
    labels: '["ieee802_11.LS", "ieee802_11.LMS", "ieee802_11.Linear Comb", "ieee802_11.STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: WiFi Channel
    labels: '[''CH1(2.412GHz)'', ''CH2(2.417GHz)'', ''CH3(2.422GHz)'', ''CH4(2.427GHz)'', ''CH5(2.432GHz)'', ''CH6(2.437GHz)'', ''CH7(2.442GHz)'', ''CH8(2.447GHz)'', ''CH9(2.452GHz)'', ''CH10(2.457GHz)'', ''CH11(2.462GHz)'', ''CH12(2.467GHz)'', ''CH13(2.472GHz)'', ''CH14(2.484GHz)'', ''CH32(5.16e9)'', ''CH36(5.18e9)'', ''CH40(5.20e9)'', ''CH44(5.22e9)'', ''CH48(5.24e9)'', ''CH52(5.26e9)'', ''CH56(5.28e9)'', ''CH60(5.30e9)'', ''CH64(5.32e9)'', ''CH68(5.34e9)'', ''CH96(5.48e9)'', ''CH100(5.50e9)'', ''CH104(5.52e9)'', ''CH108(5.54e9)'', ''CH112(5.56e9)'', ''CH116(5.58e9)'', ''CH120(5.60e9)'', ''CH124(5.62e9)'', ''CH128(5.64e9)'', ''CH132(5.66e9)'', ''CH136(5.68e9)'', ''CH140(5.70e9)'', ''CH144(5.72e9)'', ''CH149(5.745e9)'', ''CH153(5.765e9)'', ''CH157(5.785e9)'', ''CH161(5.805e9)'', ''CH165(5.825e9)'', ''CH169(5.845e9)'', ''CH173(5.865e9)'', ''CH177(5.885e9)'']'
    num_opts: '0'
    options: '[2412000000, 2417000000, 2422000000, 2427000000, 2432000000, 2437000000, 2442000000, 2447000000, 2452000000, 2457000000, 2462000000, 2467000000, 2472000000, 2484000000, 5160000000, 5180000000, 5200000000, 5220000000, 5240000000, 5260000000, 5280000000, 5300000000, 5320000000, 5340000000, 5480000000, 5500000000, 5520000000, 5540000000, 5560000000, 5580000000, 5600000000, 5620000000, 5640000000, 5660000000, 5680000000, 5700000000, 5720000000, 5745000000, 5765000000, 5785000000, 5805000000, 5825000000, 5845000000, 5865000000, 5885000000]'
    type: int
    value: '2412000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: Sync Short Threshold
    start: '0.1'
    step: '0.01'
    stop: '0.99'
    value: '0.8'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '240'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/wagner/Desktop/FEUP/MEEC/4_Ano/1semestre/CDIG/CDIG-T02-G08/wireshark.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wagner/Desktop/FEUP/MEEC/4_Ano/1semestre/CDIG/Wifi_Project_Baseband_recordings/Wifi_Project_Baseband_recordings/Sample3_20MHz_Channel100.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from PyQt5 import Qt
      from gnuradio import qtgui
      from PyQt5 import QtCore
      from PyQt5.QtCore import QObject, pyqtSlot
      from gnuradio import blocks
      import pmt
      from gnuradio import blocks, gr
      from gnuradio import fft
      from gnuradio.fft import window
      from gnuradio import filter
      from gnuradio.filter import firdes
      from gnuradio import gr
      import sys
      import signal
      from PyQt5 import Qt
      from argparse import ArgumentParser
      from gnuradio.eng_arg import eng_float, intx
      from gnuradio import eng_notation
      import foo
      import ieee802_11



      # Custom message handler for WiFi info
      class wifi_info_printer(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="WiFi Info Printer",
                  in_sig=None,
                  out_sig=None)
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)
          
          def handle_msg(self, msg):
              try:
                  meta = pmt.car(msg)
                  ssid = pmt.dict_ref(meta, pmt.intern('ssid'), pmt.PMT_NIL)
                  freq = pmt.dict_ref(meta, pmt.intern('nominal frequency'), pmt.PMT_NIL)
                  
                  if not pmt.is_null(ssid) and not pmt.is_null(freq):
                      ssid_str = pmt.symbol_to_string(ssid)
                      freq_val = pmt.to_double(freq)
                      channel = self.freq_to_channel(freq_val)
                      print(f"SSID: {ssid_str}  |  Channel: {channel} ({freq_val/1e9:.2f} GHz)")
              except Exception as e:
                  pass
          
          def freq_to_channel(self, freq_hz):
              # 5 GHz band channels
              if 5000e6 < freq_hz < 6000e6:
                  channel = int((freq_hz - 5000e6) / 5e6)
                  return channel
              # 2.4 GHz band channels
              elif 2400e6 < freq_hz < 2500e6:
                  if freq_hz == 2484e6:
                      return 14
                  else:
                      return int((freq_hz - 2407e6) / 5e6)
              return "Unknown"
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1] * window_size'
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1] * window_size'
    type: fff
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: algorithm
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: '240'
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: threshold
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '20000000'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      from PyQt5 import QtCore

      # Channel sweep setup
      channels = [
          2412000000, 2417000000, 2422000000, 2427000000, 2432000000, 2437000000,
          2442000000, 2447000000, 2452000000, 2457000000, 2462000000, 2467000000,
          2472000000, 2484000000, 5160000000, 5180000000, 5200000000, 5220000000,
          5240000000, 5260000000, 5280000000, 5300000000, 5320000000, 5340000000,
          5480000000, 5500000000, 5520000000, 5540000000, 5560000000, 5580000000,
          5600000000, 5620000000, 5640000000, 5660000000, 5680000000, 5700000000,
          5720000000, 5745000000, 5765000000, 5785000000, 5805000000, 5825000000,
          5845000000, 5865000000, 5885000000
      ]
      channel_index = [0]
      tb = self  # Captura referência do top_block

      def sweep_channel():
          try:
              print(f"[SWEEP] Mudando para canal {channel_index[0]+1}/{len(channels)}...")
              tb.set_freq(channels[channel_index[0]])
              print(f"[SWEEP] Agora em: {channels[channel_index[0]]/1e9:.3f} GHz")
              channel_index[0] = (channel_index[0] + 1) % len(channels)
          except Exception as e:
              print(f"[SWEEP] ERRO: {e}")

      print("[SWEEP] Iniciando sweep automático de canais WiFi...")

      # Criar timer e guardar como atributo do top_block para não ser coletado
      self._sweep_timer = QtCore.QTimer(self)
      self._sweep_timer.timeout.connect(sweep_channel)
      self._sweep_timer.start(10000)  # 10000ms = 10 segundos
      print("[SWEEP] Timer iniciado! Mudando de canal a cada 10 segundos...")
    section: main_after_init
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '1']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_0, '0', ieee802_11_sync_short_0, '1']
- [fir_filter_xxx_0_0, '0', blocks_divide_xx_0, '1']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_parse_mac_0, out, epy_block_1, in]
- [ieee802_11_parse_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_1, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', blocks_delay_0, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
